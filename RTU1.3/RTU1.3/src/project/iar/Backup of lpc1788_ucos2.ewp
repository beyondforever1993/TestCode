# IAR project Backup of lpc1788_ucos2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../cmsis/Core/CM3/CoreSupport; ../../cmsis/Core/CM3/DeviceSupport/NXP/LPC177x_8x; ../../cmsis/Drivers/include; ../../ucos2/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR; ../../ucos2/uCOS-II/Source; ../../app; ../../bsp; ../../util
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc1788_ucos2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: history.txt
  group app
    ../../app/: app_cfg.h app_hooks.c main.c os_cfg.h task1.c task1.h task2.c task2.h task3.c task3.h task4.c task4.h task5.c task5.h task6.c task6.h task7.c task7.h
  group bsp
    ../../bsp/: uart.c uart.h
  group cmsis
    ../../cmsis/Core/CM3/CoreSupport/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h
    ../../cmsis/Core/CM3/DeviceSupport/NXP/LPC177x_8x/: LPC177x_8x.h system_LPC177x_8x.c system_LPC177x_8x.h
    ../../cmsis/Drivers/source/: lpc177x_8x_adc.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_eeprom.c lpc177x_8x_emac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c
    ../../cmsis/Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/iar/: startup_LPC177x_8x.s
  group ucos-ii/cortex-m3
    ../../ucos2/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group ucos-ii/sources
    ../../ucos2/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
